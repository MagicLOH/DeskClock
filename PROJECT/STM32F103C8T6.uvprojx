# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c include: ..\SYSLIB;..\SYSTEM\LED;..\SYSTEM\BEEP;..\SYSTEM\KEY;..\SYSTEM\DELAY;..\SYSTEM\SYS;..\SYSTEM\USART;..\SYSTEM\TIM;..\SYSTEM\EXTI;..\SYSTEM\RTC;..\SYSTEM\DS18B20;..\SYSTEM\OLED;..\SYSTEM\DMA;..\SYSTEM\ESP8266;..\SYSTEM\MENU;..\SYSTEM\WHILE1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYSLIB
    ../SYSLIB/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/LED/: led.c
    ../SYSTEM/BEEP/: beep.c
    ../SYSTEM/KEY/: key.c
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/USART/: usart.c
    ../SYSTEM/TIM/: timer.c
    ../SYSTEM/EXTI/: exti.c
    ../SYSTEM/RTC/: rtc.c
    ../SYSTEM/DS18B20/: ds18b20.c
    ../SYSTEM/OLED/: oled.c oled_font.c
    ../SYSTEM/DMA/: dma.c
    ../SYSTEM/ESP8266/: esp8266.c
    ../SYSTEM/MENU/: menu.c
    ../SYSTEM/WHILE1/: while1.c
  group USER
    ../USER/: main.c
